#pragma once
// 5x7 font for text effects: A-Z, 0-9, space ! - . :; lowercase draws as uppercase, anything else
// as a space. Five column bytes per glyph, bit 0 = top row.

#include <stdint.h>

namespace lab {

constexpr uint8_t kGlyphW = 5;
constexpr uint8_t kGlyphH = 7;

inline const uint8_t* glyph(char c) {
  static const uint8_t kSpace[kGlyphW] = {0x00, 0x00, 0x00, 0x00, 0x00};
  static const uint8_t kPunct[][kGlyphW] = {
      {0x00, 0x00, 0x5F, 0x00, 0x00},  // !
      {0x08, 0x08, 0x08, 0x08, 0x08},  // -
      {0x00, 0x60, 0x60, 0x00, 0x00},  // .
      {0x00, 0x36, 0x36, 0x00, 0x00},  // :
  };
  static const uint8_t kDigits[][kGlyphW] = {
      {0x3E, 0x51, 0x49, 0x45, 0x3E}, {0x00, 0x42, 0x7F, 0x40, 0x00},
      {0x42, 0x61, 0x51, 0x49, 0x46}, {0x21, 0x41, 0x45, 0x4B, 0x31},
      {0x18, 0x14, 0x12, 0x7F, 0x10}, {0x27, 0x45, 0x45, 0x45, 0x39},
      {0x3C, 0x4A, 0x49, 0x49, 0x30}, {0x01, 0x71, 0x09, 0x05, 0x03},
      {0x36, 0x49, 0x49, 0x49, 0x36}, {0x06, 0x49, 0x49, 0x29, 0x1E},
  };
  static const uint8_t kLetters[][kGlyphW] = {
      {0x7E, 0x11, 0x11, 0x11, 0x7E}, {0x7F, 0x49, 0x49, 0x49, 0x36},  // A B
      {0x3E, 0x41, 0x41, 0x41, 0x22}, {0x7F, 0x41, 0x41, 0x22, 0x1C},  // C D
      {0x7F, 0x49, 0x49, 0x49, 0x41}, {0x7F, 0x09, 0x09, 0x09, 0x01},  // E F
      {0x3E, 0x41, 0x49, 0x49, 0x7A}, {0x7F, 0x08, 0x08, 0x08, 0x7F},  // G H
      {0x00, 0x41, 0x7F, 0x41, 0x00}, {0x20, 0x40, 0x41, 0x3F, 0x01},  // I J
      {0x7F, 0x08, 0x14, 0x22, 0x41}, {0x7F, 0x40, 0x40, 0x40, 0x40},  // K L
      {0x7F, 0x02, 0x0C, 0x02, 0x7F}, {0x7F, 0x04, 0x08, 0x10, 0x7F},  // M N
      {0x3E, 0x41, 0x41, 0x41, 0x3E}, {0x7F, 0x09, 0x09, 0x09, 0x06},  // O P
      {0x3E, 0x41, 0x51, 0x21, 0x5E}, {0x7F, 0x09, 0x19, 0x29, 0x46},  // Q R
      {0x46, 0x49, 0x49, 0x49, 0x31}, {0x01, 0x01, 0x7F, 0x01, 0x01},  // S T
      {0x3F, 0x40, 0x40, 0x40, 0x3F}, {0x1F, 0x20, 0x40, 0x20, 0x1F},  // U V
      {0x3F, 0x40, 0x38, 0x40, 0x3F}, {0x63, 0x14, 0x08, 0x14, 0x63},  // W X
      {0x07, 0x08, 0x70, 0x08, 0x07}, {0x61, 0x51, 0x49, 0x45, 0x43},  // Y Z
  };
  if (c >= 'a' && c <= 'z') c = static_cast<char>(c - 'a' + 'A');
  if (c >= 'A' && c <= 'Z') return kLetters[c - 'A'];
  if (c >= '0' && c <= '9') return kDigits[c - '0'];
  switch (c) {
    case '!':
      return kPunct[0];
    case '-':
      return kPunct[1];
    case '.':
      return kPunct[2];
    case ':':
      return kPunct[3];
    default:
      return kSpace;
  }
}

}  // namespace lab
